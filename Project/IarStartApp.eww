<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ASR_S32K144_Start.ewp</path>
    </project>
    <batchBuild />
</workspace>
